# IAR project cutterbox_compact.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: B:\prjts\cutterbox_compact; B:\prjts\cutterbox_compact\CMSIS\inc; B:\prjts\cutterbox_compact\Code\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS/inc
    CMSIS/inc/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h stm32f4xx.h system_stm32f4xx.h tz_context.h
  group CMSIS/src
    CMSIS/src/: system_stm32f4xx.c
  group Code/inc
    Code/inc/: bitmap.h flash_control.h I2C.h ISL_control.h libWWDG.h log.h main.h modUART.h peltier_control.h power_control.h press_button.h press_tamper.h rgb_led_control.h SFE_ISL29125.h TCS_control.h watch_dog_test.h zond_control.h
  group Code/src
    Code/src/: main.c
  group Startup
    Startup/: startup_stm32f411xe.s
